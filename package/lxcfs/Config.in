## package/lxcfs/Config.in
```kconfig
config BR2_PACKAGE_LXCFS
	bool "lxcfs"
	help
          FUSE filesystem for LXC 

	  https://linuxcontainers.org/lxcfs
```
